# Keil uVision project STC12C5A60S2-35I-LQFP48+LED+心形水晶摆台.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC12C5A60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x3FF) IROM(0-0xEFFF) CLOCK(45000000) MODP2
  output: STC12C5A60S2-35I +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\APP
  group Source Group 1
    ./: STARTUP.A51
  group User
    ./User/: main.c
  group APP
    ./APP/: 74HC595D.c
