# Keil uVision project STC15.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F2K60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: STC15 +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\Public;.\APP
  group STARTUP
    ./: STARTUP.A51
  group User
    ./User/: STC15_main.c
  group Public
    ./Public/: delay_ms.c
  group App
    ./APP/: led.c 74HC595D.c uart.c BY9301_24QS.c key.c
